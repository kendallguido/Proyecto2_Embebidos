inherit externalsrc
EXTERNALSRC = "/home/eduardo/Yocto/poky-warrior/rpi2/workspace/sources/imutils"
EXTERNALSRC_BUILD = "/home/eduardo/Yocto/poky-warrior/rpi2/workspace/sources/imutils"

# initial_rev: b28248a4f6840a075f7ef3ea551516dd07a7c94b
